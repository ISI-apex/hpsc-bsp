require qemu-xilinx.inc

XILINX_RELEASE_VERSION = "v2017.3"
XILINX_QEMU_VERSION = "v2.8.1"

# this is for tag "hpsc-0.9"
SRCREV = "hpsc-0.9"
