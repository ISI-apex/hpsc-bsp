IMAGE_INSTALL += " libgomp libgomp-dev libgomp-staticdev libc-staticdev gdbserver openssh openssh-sftp-server"
